# Repository Kreyl/Calmari

## KiCad design Calma04/Calma04_hw/Calma04.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1u; CAP_0603
C6, C8, C12: 0.1u
C7, C9, C11, C13, C14, C15: 10u
C10: 1u; CAP_0603
D1: SS14
DA1: TPS61042
DA2: NCP583SQ
DA3: MCP73832
DD1: STM32F100C4
F1, F2: FUSE0R
HOLE2: HOLE_METALLED
L1: 6.8uH; IND_1210
Q1: ALS-PT19-315C
R1, R2: 330k; RES_0603
R3: 13R; RES_0603
R4: 2k
R5, R6: 10k; RES_0603
R7: 120k; RES_0603
SW1: SWITCH
SW2: BUTTON
TP1: TESTPOINT
XL1: CONN_3
XL2: ST_SWD
XL3, XL4, XL8, XL9, XL10, XL11, XL12, XL13: CONN_1
XL5, XL6: CONN_2
XL7: USB_MICRO_B

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C8.1, C9.1, C10.1, DA2.3 (Vout), DD1.1 (VBAT), DD1.9 (VDDA), DD1.24 (VDD1), DD1.36 (VDD2), DD1.48 (VDD3), F2.2, Q1.1, XL2.1 (Vdd)
+5V: C14.1, DA3.4 (VDD), XL7.1 (UVcc)
+BATT: C6.1, C7.1, C12.1, C13.1, C15.1, DA1.3 (Vin), DA2.1 (EN), DA2.4 (Vin), DA3.3 (VBAT), F1.2, F2.1, L1.2, R2.1, SW1.2, XL10.1, XL11.1
/BAT_IN: F1.1, SW1.1, XL3.1
/BTN: DD1.10 (ADC1-0/WKUP/PA0), SW2.1, XL6.1
/Charge: DA3.1 (STAT), DD1.17 (ADC1-7/T3C2/MOSI1/PA7), XL8.1, XL9.1
/FB: DD1.14 (ADC1-4/DAC1/CK2/PA4), R7.2
/RX: DD1.31 (T1C3/RX1/PA10), XL1.1
/SB_SWCLK: DD1.37 (SWCLK/(JTCK)/(PA14)), XL2.2 (SWCLK)
/SB_SWDAT: DD1.34 (SWDIO/(JTMS)/(PA13)), XL2.4 (SWDIO)
/TX: DD1.30 (T1C2/TX1/PA9), XL1.2 (PM)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, DA1.6 (GND), DA1.PAD (GND), DA2.2 (GND), DA3.2 (GND), DD1.8 (VSSA), DD1.23 (VSS1), DD1.35 (VSS2), DD1.44 (BOOT0), DD1.47 (VSS3), HOLE2.Hle, R1.2, R3.2, R4.2, R5.2, SW2.2, XL1.3, XL2.3 (GND), XL4.1, XL6.2 (PM), XL7.4 (UGND), XL7.5 (UID), XL7.SHLD, XL12.1, XL13.1
unnamed: C1.1, DD1.19 (PB1/T3C4/ADC1-9), Q1.2, R5.1
unnamed: DD1.7 (NRST), TP1.1
unnamed: DD1.18 (PB0/T3C3/ADC1-8), R1.1, R2.2
unnamed: DA3.5 (PROG), R4.1
unnamed: DA1.4 (FB), R6.2, R7.1
unnamed: DA1.2 (Rs), R3.1, R6.1
unnamed: DA1.5 (CTRL), DD1.11 (ADC1-1/T2C2/PA1)
unnamed: DA1.1 (LED), XL5.2 (PM)
unnamed: C11.1, D1.C, DA1.7 (OVP), XL5.1
unnamed: D1.A, DA1.8 (SW), L1.1

Notes on the sheet:
-BATTERY
+BATTERY
In case of 2xAA, no LDO is required. Solder fuse instead.
Battery measurement
LEDs (4...8)
Choose capacitor max voltage carefully (30v recommended)
Button
R=252/Iled[mA]
Li-Ion charger 2k => 0.5 A
USB
Connectors for spliting pcb
Place resistor somehow if LED Off during power-up is required

Board: 2 copper layers, 52.2 x 25.0 mm, 48 parts (1 on the bottom side), 22 nets.

## KiCad design TittaCalma/TittaCalma.kicad_pcb

Parts:
B1: BAT
C1, C2, C4: 0.1u; CAP_0603
C3: 1u; CAP_0603
D1: LED
DD1: STM32F050K4_6
R1: 51R; RES_0603
SW1: BUTTON
TP1: TESTPOINT
XL1: CONN_2
XL3: ST_SWD
XL4: CONN_3

Connections:
+BATT: B1.A, C1.1, C2.1, C3.1, C4.1, DD1.1 (VDD), DD1.5 (VDDA), DD1.17 (VDD), XL3.1 (Vdd)
/RX: DD1.20 (T1C3/RX1/PA10), XL4.1
/SB_SWCLK: DD1.24 (SWCLK/(PA14)), XL3.2 (SWCLK)
/SB_SWDAT: DD1.23 (IROUT/SWDAT/(PA13)), XL3.4 (SWDIO)
/TX: DD1.19 (T1C2/TX1/PA9), XL4.2 (PM)
GND: B1.C, C1.2, C2.2, C3.2, C4.2, D1.C, DD1.31 (BOOT0), DD1.PAD (VSS/VSSA), SW1.2, XL1.2 (PM), XL3.3 (GND), XL4.3
unnamed: D1.A, R1.2, XL1.1
unnamed: DD1.6 (T2C1ETR/ADC0/WKUP1/PA0), SW1.1
unnamed: DD1.25 (NSS1/T2C1ETR/PA15), R1.1
unnamed: DD1.4 (NRST), TP1.1

Board: 2 copper layers, 24.9 x 16.3 mm, 13 parts (1 on the bottom side), 10 nets.

## Commit log

2015-08-05 Everything old here
2015-08-05 Seems like release
2015-08-08 Calma04 sch renewed
